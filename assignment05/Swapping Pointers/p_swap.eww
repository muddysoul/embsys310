<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\assignment04\Queue Demo\Module05_Demo08_Queue\main.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\p_swap.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\assignment04\Stack Party\stack.ewp</path>
    </project>
    <batchBuild />
</workspace>
